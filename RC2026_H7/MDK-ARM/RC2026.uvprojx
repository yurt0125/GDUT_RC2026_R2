# Keil uVision project RC2026.uvprojx, settings and files
target RC2026 (6220000::V6.22::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: RC2026 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,__FPU_PRESENT = 1U,__VFP_FP__ = 1,ARM_MATH_CM7
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../RC26_Lib/Inc;../RC26_User/Inc;../RC26_Motor/Inc;../RC26_Ros_Interface/Inc;../RC26_Api/Inc;../RC26_Path/Inc;../RC26_Gantry/Inc
  asm include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_cordic.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c cordic.c dma.c fdcan.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group RC26_Api
    ../RC26_Api/Src/: RC_can.cpp RC_cdc.cpp RC_gpio_exti.cpp RC_serial.cpp RC_task.cpp RC_tim.cpp RC_chassis.cpp RC_timer.cpp
    ../RC26_Api/Inc/: RC_can.h RC_cdc.h RC_gpio_exti.h RC_serial.h RC_task.h RC_tim.h RC_chassis.h RC_timer.h
  group RC26_Lib
    ../RC26_Lib/Inc/: arm_matrix.h RC_pid.h RC_filter.h RC_nonlinear_pid.h RC_flysky.h RC_wave_generator.h RC_vector2d.h RC_vector3d.h RC_JY901S.h RC_swerve_chassis.h RC_photogate.h RC_LiDAR.h RC_oid_encoder.h RC_omni_chassis.h RC_lift_chassis.h RC_HWT101CT.h RC_head_check.h RC_QEO.h RC_imu_fusion.h RC_mini_laser.h RC_combine.h RC_fusion_ctrl.h RC_IR_communication.h RC_stick_edge.h RC_QEO_mini.h
    ../RC26_Lib/Src/: RC_pid.cpp RC_filter.cpp RC_nonlinear_pid.cpp RC_flysky.cpp RC_wava_generator.cpp RC_vector2d.cpp RC_vector3d.cpp RC_JY901S.cpp RC_swerve_chassis.cpp RC_photogate.cpp RC_LiDAR.cpp RC_oid_encoder.cpp RC_omni_chassis.cpp RC_lift_chassis.cpp RC_HWT101CT.cpp RC_head_check.cpp RC_QEO.cpp RC_imu_fusion.cpp RC_mini_laser.cpp RC_combine.cpp RC_fusion_ctrl.cpp RC_IR_communication.cpp RC_stick_edge.cpp RC_QEO_mini.cpp
  group RC26_Motor
    ../RC26_Motor/Src/: RC_motor.cpp RC_dm_motor.cpp RC_dji_motor.cpp RC_m2006.cpp RC_m3508.cpp RC_m6020.cpp RC_go.cpp RC_dm4310.cpp RC_j60.cpp RC_vesc.cpp RC_rs04.cpp RC_dm4340.cpp
    ../RC26_Motor/Inc/: RC_motor.h RC_dm_motor.h RC_dji_motor.h RC_m2006.h RC_m3508.h RC_m6020.h RC_go.h RC_dm4310.h RC_j60.h RC_vesc.h RC_rs04.h RC_dm4340.h
  group RC26_Path
    ../RC26_Path/Src/: RC_curve.cpp RC_event3.cpp RC_path3.cpp RC_traj_plan3.cpp RC_traj_track3.cpp RC_head_ctrl.cpp RC_path_plan3.cpp RC_map_graph.cpp RC_graph_plan.cpp RC_navigation.cpp RC_point_lock.cpp
    ../RC26_Path/Inc/: RC_curve.h RC_event3.h RC_path3.h RC_traj_plan3.h RC_traj_track3.h RC_head_ctrl.h RC_path_plan3.h RC_map_graph.h RC_graph_plan.h RC_navigation.h RC_point_lock.h
  group RC26_Gantry
    ../RC26_Gantry/Src/: RC_gantry.cpp RC_get_KFS.cpp RC_suction.cpp RC_put_KFS.cpp RC_get_weapon_head.cpp RC_gripper.cpp RC_dock.cpp RC_aim.cpp
    ../RC26_Gantry/Inc/: RC_gantry.h RC_get_KFS.h RC_suction.h RC_put_KFS.h RC_get_weapon_head.h RC_gripper.h RC_dock.h RC_aim.h
  group RC26_Ros_Interface
    ../RC26_Ros_Interface/Src/: RC_map.cpp RC_radar.cpp RC_best_path.cpp RC_KFS_pose.cpp RC_camera_dock.cpp RC_wait_R1.cpp RC_get_data.cpp
    ../RC26_Ros_Interface/Inc/: RC_map.h RC_radar.h RC_best_path.h RC_KFS_pose.h RC_camera_dock.h RC_wait_R1.h RC_get_data.h
  group RC26_User
    ../RC26_User/Src/: RC_init.cpp RC_data_pool.cpp RC_auto_ctrl.cpp
    ../RC26_User/Inc/: RC_init.h RC_data_pool.h RC_auto_ctrl.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
